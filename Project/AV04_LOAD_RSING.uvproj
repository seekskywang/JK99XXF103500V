# Keil uVision project AV04_LOAD_RSING.uvproj, settings and files
target LOAD_Ripple (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AV04_LOAD_RSING +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\drive;..\Include;..\Libraries\CMSIS\inc;..\Libraries\CMSIS\src;..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../Libraries/CMSIS/src/: core_cm3.c startup_stm32f10x_hd.s
    ../Libraries/CMSIS/inc/: core_cm3.h stm32f10x.h system_stm32f10x.h
  group Libraries
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group drive
    ../drive/: adc.c AT24C01.c BEEP.c bsp_SysTick.c clock.c DAC.c flash.c GPIO.c IIC_24C01.c iwdg.c key.c modbus.c TIM6.c usart.c AD7655.c FAN_PRO.c Menu.c me_scpi.c
  group Readme
    ../drive/: Readme.txt
